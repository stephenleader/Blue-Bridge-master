# Keil uVision project BS18B20外设开发.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BS18B20外设开发 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 外设设计开发.c onewire.c xmf_smg_ca.c
