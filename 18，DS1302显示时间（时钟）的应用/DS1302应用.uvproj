# Keil uVision project DS1302应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS1302应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main1.c ds1302.c xmf_smg_ca.c
